# Keil uVision project ZHOS.uvprojx, settings and files
target ZHOS (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ZHOS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\ZHOS\inc;.\APP\inc;.\CORE\inc;.\STM32F10x_FWLib\inc;.\SYS\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ZHOS
    ./ZHOS/src/: lw_oopc.c memory.c switch.c log.c queue.c ZHOS.c
    ./ZHOS/inc/: ZHOS.h
  group CORE
    ./CORE/src/: core_cm3.c startup_stm32f10x_hd.s
  group SYS
    ./SYS/src/: sys.c system_stm32f10x.c
  group STM32F10x_FWLib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c
  group APP
    ./APP/src/: main.c
    ./APP/inc/: stm32f10x_conf.h
